PACKAGECONFIG_append_aglcontainerivi = " sql-sqlite "
